# Keil uVision project CH552_KeyboardEmu.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: CH552_KeyboardEmu +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Public/: DEBUG.H DEBUG.C CH552.H CH552.INC CH554.H CH554.INC
    ./USB/Device/: Keyboard.C
